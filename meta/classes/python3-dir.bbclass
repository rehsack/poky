PYTHON_BASEVERSION = "3.7"
# [d][m][u]
# d: py_debug
# m: my_malloc
# u: wide-char unicode
PYTHON_ABI = "m"
PYTHON_DIR = "python${PYTHON_BASEVERSION}"
PYTHON_PN = "python3"
PYTHON_SITEPACKAGES_DIR = "${libdir}/${PYTHON_DIR}/site-packages"
